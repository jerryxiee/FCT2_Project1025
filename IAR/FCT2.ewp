# IAR project FCT2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205zx ST STM32F205zx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\CMSIS; ..\stm32f2xx_stdperiph_lib\inc; ..\stm32f2xx_stdperiph_lib\src; ..\UserApp\inc; ..\UserApp\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FCT003_20131028.bin
  ILINK.IlinkOutputFile: FCT2.out
  ILINK.IlinkIcfFile: E:\workStation\FCT2_Project1025\CMSIS\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: FCT2.hex
  ILINK.IlinkIcfFile: E:\Project\FCT\Pro2\CMSIS\stm32f2xx_flash.icf
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f2xx.s Stm32f2xx.h stm32f2xx_conf.h stm32f2xx_it.c stm32f2xx_it.h system_stm32f2xx.c system_stm32f2xx.h
  group stm32f2xx_stdperiph_lib/inc
    ../stm32f2xx_stdperiph_lib/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
  group stm32f2xx_stdperiph_lib/src
    ../stm32f2xx_stdperiph_lib/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group UserApp/inc
    ../UserApp/inc/: ApiGeneral.h Bsp.h FIFOQueue.h HC595.h Include.h LCD_13264.h MsgCode.h spi_flash.h Test.h
  group UserApp/src
    ../UserApp/src/: ApiGeneral.c Bsp.c FIFOQueue.c HC595.c LCD_13264.C main.c spi_flash.c Test.c
